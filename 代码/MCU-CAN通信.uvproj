# Keil uVision project MCU-CAN通信.uvproj, settings and files
target MCU-CAN (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: MCU-CAN通信 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51
    ./source/: main.c MCP2515.c SPI.c UART.c
  group Include
    ./include/: MCP2515.h SPI.h UART.h config.h
